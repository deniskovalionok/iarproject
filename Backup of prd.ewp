# IAR project Backup of prd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_DISCO_REVB
  ICCARM.CCIncludePath2: Drivers\CMSIS\Include; Drivers\STM32L4xx_HAL_Driver\Inc; Drivers\CMSIS\Device\ST\STM32L4xx\Include; Drivers\STM32L4xx_HAL_Driver\Inc; Drivers\BSP\STM32L476G-Discovery; Drivers\BSP\STM32L4xx_Nucleo_32; Drivers\BSP\Components\Common; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: prd.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: D:\IARARMProjects\PRD\stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp main.h pinout.txt startup_stm32l476xx.s stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_it.h types.h
  group Drivers/BSP/STM32L476G-Discovery
    Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_spi.c
  group LCD
    ./: graphic.c graphic.h lcd.c lcd.h
